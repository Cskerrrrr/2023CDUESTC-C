# Keil uVision project 送药车.uvprojx, settings and files
target 电赛3轮车 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\UserProject;..\STM32F10x_Lib\inc;..\Core;..\system;..\HDR;.\Listings;.\Objects;..\UserProject;..\HDR\delay;..\HDR\ENCODER;..\HDR\EXTI;..\HDR\HC-SR04;..\HDR\key;..\HDR\LCD;..\HDR\LED;..\HDR\MOTOR;..\HDR\MPU6050;..\HDR\PID;..\HDR\sys;..\HDR\timer;..\HDR\usart;..\HDR\USART2;..\HDR\usart3;..\HDR\xunji;..\UserProject;..\HDR\MPU6050\eMPL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c GUI.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HDR
    ../HDR/ENCODER/: encoder.c
    ../HDR/MOTOR/: motor.c
    ../HDR/USART2/: usart2.c
    ../HDR/EXTI/: exti.c
    ../HDR/MPU6050/: mpu6050.c mpuiic.c
    ../HDR/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../HDR/key/: key.c
    ../HDR/timer/: timer.c
    ../HDR/LED/: led.c
    ../HDR/LCD/: lcd.c
    ../HDR/PID/: pid.c
    ../HDR/usart3/: usart3.c
  group system
    ../system/: delay.c sys.c usart.c
